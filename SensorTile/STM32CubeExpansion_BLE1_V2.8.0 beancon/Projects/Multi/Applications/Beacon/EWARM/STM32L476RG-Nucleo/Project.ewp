# IAR project Project.ewp, settings and files
configuration URL_Beacon (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER; EDDYSTONE_BEACON_TYPE=EDDYSTONE_URL_BEACON_TYPE
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Beacon_URL_L476RG.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UID_Beacon (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; STM32_SENSORTILE; USE_HAL_DRIVER; EDDYSTONE_BEACON_TYPE=EDDYSTONE_UID_BEACON_TYPE
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\SensorTile; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm
  OBJCOPY.OOCOutputFile: Beacon_UID_L476RG.bin
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../../Src/: bluenrg_interface.c cube_hal_l4.c eddystone_beacon.c main.c sensor_service.c stm32l4xx_hal_msp.c stm32xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
  group Drivers/BSP/SensorTile
    ../../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_accelero.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
